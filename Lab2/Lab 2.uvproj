# Keil uVision project Lab 2.uvproj, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab 2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: lab2main.c system_stm32f10x.c findHighBitC-template.c Lab2-ASM-template.S startup_stm32f10x_md.s
