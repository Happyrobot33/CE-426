# Keil uVision project CMSISrtxSignals.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: CMSISrtxSignals
  c flags: Optim=2 v6Lang=3 v6LangP=3
  c misc: -fno-data-sections
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:LED 2.0.0, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
